options:
  parameters:
    description: 802.11a/g/n/ac frames from a USB Wi-Fi SDR through gr-ieee80211's SISO receiver, without a GUI
    generate_options: no_gui
    id: wifi_rx_ieee80211
    output_language: python
    run_options: run
    title: USB Wi-Fi SDR 802.11a/g/n/ac receive test (gr-ieee80211)
  states: {}

blocks:
- name: freq
  id: parameter
  parameters:
    label: Center frequency
    short_id: f
    type: eng_float
    value: 5180e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: RF gain
    short_id: g
    type: eng_float
    value: '14'
  states: {}
- name: agc
  id: parameter
  parameters:
    label: AGC
    short_id: a
    type: intx
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: src
  id: soapy_uwifisdr_source
  parameters:
    type: fc32
    device: ''
    dev_args: ''
    samp_rate: samp_rate
    center_freq: freq
    agc: bool(agc)
    gain: gain
  states: {}
- name: delay_16
  id: blocks_delay
  parameters:
    type: complex
    delay: '16'
  states: {}
- name: corr
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: corr_avg
  id: blocks_moving_average_xx
  parameters:
    type: complex
    length: '48'
    scale: '1'
    max_iter: '4000'
  states: {}
- name: corr_mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: power
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: power_avg
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '64'
    scale: '1'
    max_iter: '4000'
  states: {}
- name: norm
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: trigger
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: sync
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: sig_field
  id: ieee80211_signal
  parameters: {}
  states: {}
- name: demod
  id: ieee80211_demod
  parameters:
    mupos: '0'
    mugid: '2'
  states: {}
- name: decode
  id: ieee80211_decode
  parameters: {}
  states: {}
- name: packets
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}

connections:
- [src, '0', delay_16, '0']
- [src, '0', corr, '1']
- [src, '0', power, '0']
- [src, '0', sync, '2']
- [src, '0', sig_field, '1']
- [delay_16, '0', corr, '0']
- [corr, '0', corr_avg, '0']
- [corr_avg, '0', corr_mag, '0']
- [corr_avg, '0', sync, '1']
- [power, '0', power_avg, '0']
- [corr_mag, '0', norm, '0']
- [power_avg, '0', norm, '1']
- [norm, '0', trigger, '0']
- [trigger, '0', sync, '0']
- [sync, '0', sig_field, '0']
- [sig_field, '0', demod, '0']
- [demod, '0', decode, '0']
- [decode, out, packets, store]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
