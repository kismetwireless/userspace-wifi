options:
  parameters:
    description: 802.11a/g frames from a USB Wi-Fi SDR through gr-ieee802-11's receiver, without a GUI
    generate_options: no_gui
    id: wifi_rx_ieee802_11
    output_language: python
    run_options: run
    title: USB Wi-Fi SDR 802.11a/g receive test (gr-ieee802-11)
  states: {}

blocks:
- name: freq
  id: parameter
  parameters:
    label: Center frequency
    short_id: f
    type: eng_float
    value: 5180e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: RF gain
    short_id: g
    type: eng_float
    value: '14'
  states: {}
- name: agc
  id: parameter
  parameters:
    label: AGC
    short_id: a
    type: intx
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: src
  id: soapy_uwifisdr_source
  parameters:
    type: fc32
    device: ''
    dev_args: ''
    samp_rate: samp_rate
    center_freq: freq
    agc: bool(agc)
    gain: gain
  states: {}
- name: delay_16
  id: blocks_delay
  parameters:
    type: complex
    delay: '16'
  states: {}
- name: conj
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: mult
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: corr_avg
  id: blocks_moving_average_xx
  parameters:
    type: complex
    length: window_size
    scale: '1'
    max_iter: '4000'
  states: {}
- name: corr_mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: power
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: power_avg
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: window_size + 16
    scale: '1'
    max_iter: '4000'
  states: {}
- name: norm
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: sync_short
  id: ieee802_11_sync_short
  parameters:
    threshold: '0.56'
    min_plateau: '2'
    log: 'False'
    debug: 'False'
  states: {}
- name: delay_sync
  id: blocks_delay
  parameters:
    type: complex
    delay: sync_length
  states: {}
- name: sync_long
  id: ieee802_11_sync_long
  parameters:
    sync_length: sync_length
    log: 'False'
    debug: 'False'
  states: {}
- name: to_vector
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '64'
  states: {}
- name: ofdm_fft
  id: fft_vxx
  parameters:
    type: complex
    fft_size: '64'
    forward: 'True'
    window: window.rectangular(64)
    shift: 'True'
  states: {}
- name: equalizer
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.LS
    freq: freq
    bw: samp_rate
    log: 'False'
    debug: 'False'
  states: {}
- name: decode_mac
  id: ieee802_11_decode_mac
  parameters:
    log: 'False'
    debug: 'False'
  states: {}

connections:
- [src, '0', delay_16, '0']
- [src, '0', mult, '0']
- [src, '0', power, '0']
- [delay_16, '0', conj, '0']
- [delay_16, '0', sync_short, '0']
- [conj, '0', mult, '1']
- [mult, '0', corr_avg, '0']
- [corr_avg, '0', corr_mag, '0']
- [corr_avg, '0', sync_short, '1']
- [power, '0', power_avg, '0']
- [corr_mag, '0', norm, '0']
- [power_avg, '0', norm, '1']
- [norm, '0', sync_short, '2']
- [sync_short, '0', delay_sync, '0']
- [sync_short, '0', sync_long, '0']
- [delay_sync, '0', sync_long, '1']
- [sync_long, '0', to_vector, '0']
- [to_vector, '0', ofdm_fft, '0']
- [ofdm_fft, '0', equalizer, '0']
- [equalizer, '0', decode_mac, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
